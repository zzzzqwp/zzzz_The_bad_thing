# Keil uVision project Omnidirectional_Wheels_chassis_F407_240301.Omnidirectional_Wheels_chassis_F407_240301.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Omnidirectional_Wheels_chassis_F407_240301
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx USE_HAL_DRIVER
  c misc: --cpp
  c include: ../Core/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../RM_File
  memory RVCT4: RAM 0x8000000 size 0x100000
  memory RVCT9: ROM 0x20000000 size 0x20000
  memory RVCT10: ROM 0x10000000 size 0x10000
  scatter file: ./Omnidirectional_Wheels_chassis_F407_240301.Omnidirectional_Wheels_chassis_F407_240301.sct
  link misc: --entry=Reset_Handler --info summarysizes --load_addr_map_info --summary_stderr
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.cpp gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group RM_FILE
    ../RM_File/: ladrc.h RM_Can.h RM_Clicker.h RM_Filter.h RM_Key.h RM_Motor.h RM_Pid.h RM_StaticTime.h RM_stdxxx.h RM_stm32fxxx_hal.h Total_stack.h RM_Wheel.h RM_PM01.h def_variable.h RM_RefereeSystemCRC.h RM_RefereeSystem.h RM_RefereeSystemCRC.cpp RM_RefereeSystem.cpp
software components: CMSIS:CORE 5.4.0
